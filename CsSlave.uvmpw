<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <WorkspaceName>WorkSpace</WorkspaceName>

  <project>
    <PathAndName>.\CsSlave_Bootloader\MDK-ARM\CsSlave_bootloader.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\CsSlave_App\MDK-ARM\CsSlave_app.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\CsSlave_App\MDK-ARM\CsSlave_app_lib.uvprojx</PathAndName>
    <NodeIsActive>1</NodeIsActive>
  </project>

</ProjectWorkspace>
