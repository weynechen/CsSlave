# Keil uVision project CsSlave_app_lib.uvprojx, settings and files
target CsSlave_app (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CsSlave_app +hex (library)
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src/drivers;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;..\Bsp\cdce;..\Bsp\ssd2828;..\Bsp\power;..\Protocol;..\Bsp\sysconfig;..\Algorithm\pattern;..\Bsp\fpga;..\Bsp\res;..\Bsp\lcd;..\Bsp\flash_if;..\Bsp\spi_flash;..\Algorithm\upgrade;..\USBConfig;..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;..\Bsp\ctlbox;..\Bsp\rgb_if;..\Bsp\flickersensor;..\Bsp\tp
  library: MicroLIB
  memory RVCT4: ROM 0x801c800 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff.c diskio.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: main.c stm32f1xx_it.c task.c mtp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_crc.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_sd.c stm32f1xx_hal.c stm32f1xx_hal_pcd.c stm32f1xx_hal_sram.c stm32f1xx_ll_usb.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_spi.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Application/Bsp
    ../Src/: bsp_driver_sd.c
    ../Bsp/cdce/: cdce913.c
    ../Bsp/ssd2828/: ssd2828.c
    ../Bsp/sysconfig/: sysconfig.c
    ../Bsp/power/: power.c
    ../Bsp/lcd/: lcd.c
    ../Bsp/fpga/: fpga.c
    ../Bsp/res/: res.c
    ../Bsp/flash_if/: flash_if.c
    ../Bsp/spi_flash/: spi_flash.c
    ../Bsp/ctlbox/: ctrlbox.c
    ../Bsp/rgb_if/: rgbif.c
    ../Bsp/flickersensor/: flickersensor.c
    ../Bsp/tp/: tp.c
    ../Protocol/: ppro.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ioreq.c usbd_ctlreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/Protocol
    ../Protocol/: ack.c rec.c
  group Application/Algorithm
    ../Algorithm/pattern/: in_img.c
    ../Algorithm/upgrade/: upgrade.c
  group Application/HW
    ../Src/: gpio.c fsmc.c fatfs.c stm32f1xx_hal_msp.c sdio.c dma.c tim.c usart.c crc.c adc.c spi.c
  group USBConfig
    ../USBConfig/: usb_device.c usbd_cdc_if.c usbd_composite.c usbd_conf.c usbd_desc.c usbd_storage_if.c
software components: CMSIS:CORE 4.3.0
