# Keil uVision project CsSlave_Custom.uvprojx, settings and files
target CsSlave_app (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CsSlave_app +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x801c800 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: main.c mtp.c CsSlave_app.lib stm32f1xx_it.c startup_stm32f103xe.s
software components: CMSIS:CORE 4.3.0
